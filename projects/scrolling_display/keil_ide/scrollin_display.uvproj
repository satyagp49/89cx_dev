# Keil uVision project scrollin_display.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89x516RD2 SST
  cpu: IRAM(0-0xFF) XRAM(0-0x2FF) IROM(0-0xFFFF) CLOCK(40000000)
  output: scrollin_display +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\application\include;..\core\include\arch_89cx;..\core\include
  group Source Group 1
    ../core/src/arch_89cx/: STARTUP.A51
  group core
    ../core/src/: core_sys_init.c
    ../core/src/arch_89cx/: arch_89cx.c timer_89cx.c uart_89cx.c
  group application
    ../application/src/: led_message_scrolling.c
